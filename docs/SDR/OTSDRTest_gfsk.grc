<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>title</key><value>OTRadio_gfsk</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>baud</value></param>
<param><key>value</key><value>57602</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>centre_freq</value></param>
<param><key>value</key><value>868438900</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fsk_deviation_hz</value></param>
<param><key>value</key><value>28750</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_per_sym</value></param>
<param><key>value</key><value>samp_rate/(baud)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>2.4e6</value></param>
</block>
<block>
<key>variable_tag_object</key>
<param><key>id</key><value>variable_tag_object_0</value></param>
<param><key>key</key><value>pmt.intern("sync_word")</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>src</key><value>pmt.intern("src")</value></param>
<param><key>value</key><value>pmt.intern("value")</value></param>
</block>
<block>
<key>analog_quadrature_demod_cf</key>
<param><key>id</key><value>analog_quadrature_demod_cf_0</value></param>
<param><key>gain</key><value>samp_rate/(2*math.pi*fsk_deviation_hz/8.0)</value></param>
</block>
<block>
<key>blocks_complex_to_mag_squared</key>
<param><key>id</key><value>blocks_complex_to_mag_squared_0</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/tmp/gfsk.dat</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>/home/denzo/openTRV/SDR/gfsk_example_868438900_2400000_fc.raw</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>100</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0</value></param>
<param><key>cutoff_freq</key><value>60e3</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>width</key><value>20e3</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>wxgui_scopesink2</key>
<param><key>id</key><value>wxgui_scopesink2_1</value></param>
<param><key>ac_couple</key><value>False</value></param>
<param><key>num_inputs</key><value>2</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>t_scale</key><value>1e-3</value></param>
<param><key>title</key><value>Scope Plot</value></param>
<param><key>trig_mode</key><value>wxgui.TRIG_MODE_AUTO</value></param>
<param><key>type</key><value>float</value></param>
<param><key>v_offset</key><value>0</value></param>
<param><key>v_scale</key><value>20</value></param>
<param><key>xy_mode</key><value>False</value></param>
<param><key>y_axis_label</key><value>Counts</value></param>
</block>
<connection><source_block_id>analog_quadrature_demod_cf_0</source_block_id><sink_block_id>wxgui_scopesink2_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_squared_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>wxgui_scopesink2_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>low_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>analog_quadrature_demod_cf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>blocks_complex_to_mag_squared_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
